DESCRIPTION = "Image project"

IMAGE_INSTALL = "busybox"
inherit core-image
